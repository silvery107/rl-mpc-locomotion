Commit message: disable fix link

File: assets/Xiaotian/urdf/xiaotian_description.urdf (robot description, URDF)
Before this commit: robot xiaotianhybrid, 18 links, 17 joints
Links:
- removed link root_link
Joints:
- removed joint floating_base
